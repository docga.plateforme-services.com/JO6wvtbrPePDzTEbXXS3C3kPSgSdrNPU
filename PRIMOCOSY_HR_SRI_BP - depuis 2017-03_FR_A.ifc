Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-05-26T10:03:46
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Interface utilisateur alternative 17.21.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 26 10:03:46 2020 * Host: GA17977 * Database: C:\Users\OGRAND~1\AppData\Local\Temp\{4A8723EF-7A37-4BCE-AF5C-93B920CFEB2C}\ifc * Database version: 5507 * Database creation date: Tue May 26 10:03:44 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue May 26 10:03:45 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 26 10:03:45 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 52, 0, 117187; RefLongitude: 2, 19, 59, 880409; RefElevation: 0 m

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m

# IfcBuildingElementProxy: PRIMOCOSY SRI BP, PRIMOCOSY_HR_SRI_BP - depuis 2017-03_FR_B:PRIMOCOSY SRI BP:253101
In: Niveau 0
Type - Material: Coupe
Pset_BuildingElementProxyCommon - Reference: PRIMOCOSY SRI BP
Pset_ManufacturerTypeInformation - Manufacturer: Atlantic
